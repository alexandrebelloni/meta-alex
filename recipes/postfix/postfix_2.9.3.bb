require postfix.inc

SRC_URI[postfix-2.9.3.md5sum] = "72cd4656d251fe635d9b8b065d6cc729"
SRC_URI[postfix-2.9.3.sha256sum] = "3b4ae6d7715ccd23396d83a65ad83c7639065a125c87393013cc0514186a55da"

PR = "${INC_PR}.0"
